# Keil uVision project feed6.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: FT32F030K8ATx FMD
  pack: FMD.FT32F0xx_DFP.1.1.4
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: feed6 +hex
  AfterMake: $K\ARM\ARM_Compiler_5.06u7\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\user;.\src\freertos\inc;.\src\freertos\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ./src/user/source/: main.c board_init.c exti_init.c gpio_init.c adc_init.c pwm_init.c delay.c usart_init.c motor_ctrl.c rtc_init.c systick_tick.c flash_storage.c battery_monitor.c fault_detector.c factory_reset.c task_scheduler.c key.c led.c retarget.c flash_schedule.c log.c buzzer.c audio_player.c iwdg_init.c lsi_test.c hse_init.c factory_test.c factory_wifi_test_status.c
  group tuya_sdk
    ./src/tuya_sdk/: mcu_api.c protocol.c system.c
software components: CMSIS:CORE 5.1.1, Device:FT32Driver:ADC 1.0.1, Device:FT32Driver:COMMON 1.0.1, Device:FT32Driver:CRC 1.0.1, Device:FT32Driver:CRS 1.0.1, Device:FT32Driver:DEBUG 1.0.1, Device:FT32Driver:DMA 1.0.1, Device:FT32Driver:EXTI 1.0.1, Device:FT32Driver:FLASH 1.0.1, Device:FT32Driver:GPIO 1.0.1, Device:FT32Driver:IWDG 1.0.1, Device:FT32Driver:MISC 1.0.1, Device:FT32Driver:PWR 1.0.1, Device:FT32Driver:RCC 1.0.1, Device:FT32Driver:RTC 1.0.1, Device:FT32Driver:SYSCFG 1.0.1, Device:FT32Driver:TIM 1.0.1, Device:FT32Driver:USART 1.0.1, Device:Startup 1.0.1
